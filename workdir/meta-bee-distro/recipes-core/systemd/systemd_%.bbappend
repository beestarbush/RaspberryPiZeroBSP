PACKAGECONFIG:append = " networkd"

RDEPENDS:${PN}:append = " wpa-supplicant"